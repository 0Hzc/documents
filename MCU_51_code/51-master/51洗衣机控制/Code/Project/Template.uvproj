# Keil uVision project Template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Head
  group Source
    ../Source/: button.c lcd1602.c main.c pbdata.c motor.c
  group Head
    ../Head/: button.h lcd1602.h pbdata.h motor.h
